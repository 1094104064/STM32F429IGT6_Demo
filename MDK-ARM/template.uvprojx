# Keil uVision project template.uvprojx, settings and files
target Application (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User\basic;..\User\core;..\User\bsp;..\User\lib;..\User\demo
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User/basic
    ../User/basic/: main.c log.c
  group User/core
    ../User/core/: stm32f4xx_it.c core_gpio.c core_systick.c core_usart1.c core_swiic.c core_hwiic.c core_spi1.c
  group User/bsp
    ../User/bsp/: bsp.c bsp_ioled.c bsp_tick.c bsp_console.c bsp_task.c bsp_bmp180.c bsp_w25qxx.c
  group User/algorithm
    ../User/algorithm/: alg_ringbuf.c alg_linklist.c
  group User/demo
    ../User/demo/: demo_ioled_flash_light.c demo_ioled_grad_light.c demo_console_receive.c demo_tick_delay_printf.c demo_task_printf.c demo_bmp180_test.c demo_w25qxx_test.c
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STD_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
